options:
  parameters:
    author: lion
    generate_options: qt_gui
    id: main_wifi_4rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''test|2200'',''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2000000000.0,2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000.0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.45'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: 6e6
    label2: 10e6
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 10e6
    type: real
    value: 10e6
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: MyMod_cal_multi_usrp_0
  id: MyMod_cal_multi_usrp
  parameters:
    cal_time: '64'
    en: 'True'
    method: '0'
    nin: '4'
  states: {state: disabled}
- name: addresses
  id: parameter
  parameters:
    type: str
    value: '"addr0=192.168.10.2,addr1=192.168.20.3,addr2=192.168.20.5,addr3=192.168.10.4"'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_1_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Desktop/1
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Desktop/2
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Desktop/3
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Desktop/4
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lion/Desktop/tx_signal1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '4'
    size: '200'
    srate: samp_rate
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '200'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: uhd.tune_request(freq,rf_freq=freq-lo_offset,rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq1: uhd.tune_request(freq,rf_freq=freq-lo_offset,rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq2: uhd.tune_request(freq,rf_freq=freq-lo_offset,rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq3: uhd.tune_request(freq,rf_freq=freq-lo_offset,rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_source0: external
    clock_source1: external
    clock_source2: external
    clock_source3: external
    dc_offs_enb0: 'True'
    dc_offs_enb1: 'True'
    dc_offs_enb2: 'True'
    dc_offs_enb3: 'True'
    dev_addr: addresses
    dev_args: '""'
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    iq_imbal_enb0: 'True'
    iq_imbal_enb1: 'True'
    iq_imbal_enb2: 'True'
    iq_imbal_enb3: 'True'
    nchan: '4'
    norm_gain0: 'True'
    norm_gain1: 'True'
    norm_gain2: 'True'
    norm_gain3: 'True'
    num_mboards: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    time_source2: external
    time_source3: external
    type: fc32
  states: {}
- name: wifi_4rx_hier_0
  id: wifi_4rx_hier
  parameters: {}
  states: {}

connections:
- [MyMod_cal_multi_usrp_0, '0', wifi_4rx_hier_0, '0']
- [MyMod_cal_multi_usrp_0, '1', wifi_4rx_hier_0, '1']
- [MyMod_cal_multi_usrp_0, '2', wifi_4rx_hier_0, '2']
- [MyMod_cal_multi_usrp_0, '3', wifi_4rx_hier_0, '3']
- [blocks_complex_to_arg_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_arg_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_arg_1_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_arg_1_0_0, '0', qtgui_time_sink_x_1, '3']
- [blocks_complex_to_arg_1_1, '0', qtgui_time_sink_x_1, '2']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_1_1, '0']
- [blocks_divide_xx_1, '0', blocks_complex_to_arg_1_0, '0']
- [blocks_divide_xx_1_0, '0', blocks_complex_to_arg_1_0_0, '0']
- [blocks_file_source_0, '0', MyMod_cal_multi_usrp_0, '0']
- [blocks_file_source_0, '0', MyMod_cal_multi_usrp_0, '1']
- [blocks_file_source_0, '0', MyMod_cal_multi_usrp_0, '2']
- [blocks_file_source_0, '0', MyMod_cal_multi_usrp_0, '3']
- [uhd_usrp_source_0, '0', MyMod_cal_multi_usrp_0, '0']
- [uhd_usrp_source_0, '0', wifi_4rx_hier_0, '0']
- [uhd_usrp_source_0, '1', MyMod_cal_multi_usrp_0, '1']
- [uhd_usrp_source_0, '1', wifi_4rx_hier_0, '1']
- [uhd_usrp_source_0, '2', MyMod_cal_multi_usrp_0, '2']
- [uhd_usrp_source_0, '2', wifi_4rx_hier_0, '2']
- [uhd_usrp_source_0, '3', MyMod_cal_multi_usrp_0, '3']
- [uhd_usrp_source_0, '3', wifi_4rx_hier_0, '3']
- [wifi_4rx_hier_0, '0', blocks_complex_to_arg_0, '0']
- [wifi_4rx_hier_0, '0', blocks_divide_xx_0, '0']
- [wifi_4rx_hier_0, '0', blocks_divide_xx_0_0, '0']
- [wifi_4rx_hier_0, '0', blocks_divide_xx_1, '0']
- [wifi_4rx_hier_0, '1', blocks_complex_to_arg_0_0, '0']
- [wifi_4rx_hier_0, '1', blocks_divide_xx_0, '1']
- [wifi_4rx_hier_0, '2', blocks_complex_to_arg_0_0_0, '0']
- [wifi_4rx_hier_0, '2', blocks_divide_xx_1, '1']
- [wifi_4rx_hier_0, '2', blocks_divide_xx_1_0, '0']
- [wifi_4rx_hier_0, '3', blocks_complex_to_arg_0_0_0_0, '0']
- [wifi_4rx_hier_0, '3', blocks_divide_xx_0_0, '1']
- [wifi_4rx_hier_0, '3', blocks_divide_xx_1_0, '1']

metadata:
  file_format: 1
