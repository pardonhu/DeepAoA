options:
  parameters:
    generate_options: hb_qt_gui
    id: wifi_4rx_hier
    output_language: python
    title: wifi_4rx_hier
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''test|2200'',''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2000000000.0,2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000.0'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: 6e6
    label2: 10e6
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 10e6
    type: real
    value: 10e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: samp_rate_0
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 10e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_1_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_2_1
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_1_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: hsujim_my_csv_0
  id: hsujim_my_csv
  parameters:
    path: '1'
  states: {state: disabled}
- name: hsujim_my_csv_0_0
  id: hsujim_my_csv
  parameters:
    path: '2'
  states: {state: disabled}
- name: hsujim_my_csv_0_1
  id: hsujim_my_csv
  parameters:
    path: '3'
  states: {state: disabled}
- name: hsujim_my_csv_0_1_0
  id: hsujim_my_csv
  parameters:
    path: '4'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0_1
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0_1_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0_1
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0_1_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_1
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_1_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_1
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_1_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"1"'
    size: 48*10
    type: complex
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_conjugate_cc_0_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_conjugate_cc_0_1_0, '0', blocks_multiply_xx_0_1_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_delay_0_0_0, '0', ieee802_11_sync_short_0_0, '0']
- [blocks_delay_0_0_0_0, '0', blocks_conjugate_cc_0_1, '0']
- [blocks_delay_0_0_0_0, '0', ieee802_11_sync_short_0_1, '0']
- [blocks_delay_0_0_0_0_0, '0', blocks_conjugate_cc_0_1_0, '0']
- [blocks_delay_0_0_0_0_0, '0', ieee802_11_sync_short_0_1_0, '0']
- [blocks_delay_0_1, '0', ieee802_11_sync_long_0_0, '1']
- [blocks_delay_0_2, '0', ieee802_11_sync_long_0_1, '1']
- [blocks_delay_0_2_1, '0', ieee802_11_sync_long_0_1_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_0, '2']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_1, '2']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_1_0, '2']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_moving_average_xx_1_0, '0', ieee802_11_sync_short_0_0, '1']
- [blocks_moving_average_xx_1_1, '0', ieee802_11_sync_short_0_1, '1']
- [blocks_moving_average_xx_1_1_0, '0', ieee802_11_sync_short_0_1_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_moving_average_xx_1_1, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_moving_average_xx_1_1_0, '0']
- [blocks_pdu_to_tagged_stream_1_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', fft_vxx_0_1_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [blocks_vector_to_stream_0_0, '0', pad_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', pad_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', pad_sink_0_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_null_sink_1_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_null_sink_1_0_0, '0']
- [blocks_vector_to_stream_1_0_0_0, '0', blocks_null_sink_1_0_0_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fft_vxx_0_0, '0', ieee802_11_frame_equalizer_0_0, '0']
- [fft_vxx_0_1, '0', ieee802_11_frame_equalizer_0_1, '0']
- [fft_vxx_0_1_0, '0', ieee802_11_frame_equalizer_0_1_0, '0']
- [ieee802_11_decode_mac_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_decode_mac_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [ieee802_11_decode_mac_0_1, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '0', blocks_vector_to_stream_0_0, '0']
- [ieee802_11_frame_equalizer_0, '0', blocks_vector_to_stream_1, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, '1', blocks_vector_to_stream_0, '0']
- [ieee802_11_frame_equalizer_0, '1', ieee802_11_decode_mac_0, '1']
- [ieee802_11_frame_equalizer_0, symbols, blocks_pdu_to_tagged_stream_1_0, pdus]
- [ieee802_11_frame_equalizer_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [ieee802_11_frame_equalizer_0_0, '0', ieee802_11_decode_mac_0_0, '0']
- [ieee802_11_frame_equalizer_0_0, '1', blocks_vector_to_stream_0_0_0, '0']
- [ieee802_11_frame_equalizer_0_0, '1', ieee802_11_decode_mac_0_0, '1']
- [ieee802_11_frame_equalizer_0_1, '0', blocks_vector_to_stream_1_0_0, '0']
- [ieee802_11_frame_equalizer_0_1, '0', ieee802_11_decode_mac_0_1, '0']
- [ieee802_11_frame_equalizer_0_1, '1', blocks_vector_to_stream_0_0_0_0, '0']
- [ieee802_11_frame_equalizer_0_1, '1', ieee802_11_decode_mac_0_1, '1']
- [ieee802_11_frame_equalizer_0_1_0, '0', blocks_vector_to_stream_1_0_0_0, '0']
- [ieee802_11_frame_equalizer_0_1_0, '0', ieee802_11_decode_mac_0_1_0, '0']
- [ieee802_11_frame_equalizer_0_1_0, '1', blocks_vector_to_stream_0_0, '0']
- [ieee802_11_frame_equalizer_0_1_0, '1', ieee802_11_decode_mac_0_1_0, '1']
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [ieee802_11_sync_long_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [ieee802_11_sync_long_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0_0, '0', blocks_delay_0_1, '0']
- [ieee802_11_sync_short_0_0, '0', ieee802_11_sync_long_0_0, '0']
- [ieee802_11_sync_short_0_1, '0', blocks_delay_0_2, '0']
- [ieee802_11_sync_short_0_1, '0', ieee802_11_sync_long_0_1, '0']
- [ieee802_11_sync_short_0_1_0, '0', blocks_delay_0_2_1, '0']
- [ieee802_11_sync_short_0_1_0, '0', ieee802_11_sync_long_0_1_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [pad_source_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [pad_source_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [pad_source_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [pad_source_0_0_0_0, '0', blocks_delay_0_0_0, '0']
- [pad_source_0_0_0_0, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
