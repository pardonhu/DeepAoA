options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: en
  id: variable_qtgui_chooser
  parameters:
    label: en
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: raw
    value: '1'
  states: {}
- name: en_0
  id: variable_qtgui_chooser
  parameters:
    label0: Disable
    label1: Enable
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    orient: Qt.QHBoxLayout
    type: raw
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''test|2200'',''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2000000000.0,2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000.0'
  states: {}
- name: gain_of_all
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.6'
    widget: slider
  states: {}
- name: gain_rx1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: gain_rx2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: gain_rx3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: gain_rx4
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: 6e6
    label2: 10e6
    label3: 20e6
    label4: 30e6
    num_opts: '5'
    option0: '0'
    option1: 6e6
    option2: 10e6
    option3: 20e6
    option4: 30e6
    type: real
    value: 10e6
    widget: radio_buttons
  states: {}
- name: recv
  id: variable_qtgui_chooser
  parameters:
    label0: RX2
    label1: TX/RX
    num_opts: '2'
    option0: RX2
    option1: TX/RX
    type: string
    value: RX2
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 10e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: MyMod_cal_multi_usrp_0
  id: MyMod_cal_multi_usrp
  parameters:
    cal_time: '128'
    en: en_0
    method: '1'
    nin: '4'
  states: {}
- name: addresses
  id: parameter
  parameters:
    type: str
    value: '"addr0=192.168.10.2,addr1=192.168.20.3,addr2=192.168.20.5,addr3=192.168.10.4"'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_2_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_2
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_3
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_4
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_1_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_2_1
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_1_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/RX_1
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/RX_2
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/RX_3
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/RX_4
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/O_1
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/O_2
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/O_3
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /media/lion/Elements SE/AOA/O_4
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/pattern_4rx/10_2
    type: complex
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/pattern_4rx/10_4
    type: complex
  states: {}
- name: blocks_file_sink_2_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/pattern_4rx/20_3
    type: complex
  states: {}
- name: blocks_file_sink_2_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/pattern_4rx/20_5
    type: complex
  states: {}
- name: blocks_file_sink_2_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/origin_signal/tmp/20_5
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/origin_signal/tmp/20_3
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2_0_1
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/origin_signal/tmp/10_4
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2_1
  id: blocks_file_sink
  parameters:
    file: /home/lion/Videos/origin_signal/tmp/10_2
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lion/Desktop/tx_signal1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/lion/Desktop/tx_signal1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/lion/Desktop/tx_signal1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/lion/Desktop/tx_signal1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1_1_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: hsujim_my_csv_0
  id: hsujim_my_csv
  parameters:
    path: '1'
  states: {state: disabled}
- name: hsujim_my_csv_0_0
  id: hsujim_my_csv
  parameters:
    path: '2'
  states: {state: disabled}
- name: hsujim_my_csv_0_1
  id: hsujim_my_csv
  parameters:
    path: '3'
  states: {state: disabled}
- name: hsujim_my_csv_0_1_0
  id: hsujim_my_csv
  parameters:
    path: '4'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0_1_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
    nin: '4'
  states: {state: disabled}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: chan_est
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
    nin: '4'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_1
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_0_1_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_long_2_0
  id: ieee802_11_sync_long_2
  parameters:
    debug: 'False'
    log: 'False'
    nin: '4'
    raw: 'True'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_1
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_0_1_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.57'
  states: {}
- name: ieee802_11_sync_short_2_0
  id: ieee802_11_sync_short_2
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    nin: '4'
    raw: 'False'
    threshold: '0.56'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"1"'
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 5.89e9
    fftsize: '64'
    name: '"FEQ"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"CSI Phase"'
    nconnections: '4'
    size: '1000'
    srate: samp_rate
    type: float
    ylabel: Phase
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"CSI Phase diff"'
    nconnections: '4'
    size: '400'
    srate: samp_rate
    type: float
    ylabel: Phase
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"long"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"origin"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    size: '400'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_5
  id: qtgui_time_sink_x
  parameters:
    name: '"beforebefore"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_6
  id: qtgui_time_sink_x
  parameters:
    name: '"afterafter"'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_7
  id: qtgui_time_sink_x
  parameters:
    name: '"power"'
    nconnections: '4'
    size: '80000'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: recv
    ant1: recv
    ant2: recv
    ant3: recv
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq1: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq2: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq3: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_source0: external
    clock_source1: external
    clock_source2: external
    clock_source3: external
    dc_offs_enb0: '"Enable"'
    dc_offs_enb1: '"Enable"'
    dc_offs_enb2: '"Enable"'
    dc_offs_enb3: '"Enable"'
    dev_addr: addresses
    dev_args: '""'
    gain0: gain_of_all
    gain1: gain_of_all
    gain2: gain_of_all
    gain3: gain_of_all
    iq_imbal_enb0: '"Enable"'
    iq_imbal_enb1: '"Enable"'
    iq_imbal_enb2: '"Enable"'
    iq_imbal_enb3: '"Enable"'
    nchan: '4'
    norm_gain0: 'True'
    norm_gain1: 'True'
    norm_gain2: 'True'
    norm_gain3: 'True'
    num_mboards: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    time_source2: external
    time_source3: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: recv
    ant1: recv
    ant2: recv
    ant3: recv
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq1: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq2: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq3: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_source0: external
    clock_source1: external
    clock_source2: external
    clock_source3: external
    dc_offs_enb0: '"Enable"'
    dc_offs_enb1: '"Enable"'
    dc_offs_enb2: '"Enable"'
    dc_offs_enb3: '"Enable"'
    dev_addr: addresses
    dev_args: '""'
    gain0: gain_of_all
    gain1: gain_of_all
    gain2: gain_of_all
    gain3: gain_of_all
    iq_imbal_enb0: '"Enable"'
    iq_imbal_enb1: '"Enable"'
    iq_imbal_enb2: '"Enable"'
    iq_imbal_enb3: '"Enable"'
    nchan: '4'
    norm_gain0: 'True'
    norm_gain1: 'True'
    norm_gain2: 'True'
    norm_gain3: 'True'
    num_mboards: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    time_source2: external
    time_source3: external
    type: fc32
  states: {state: disabled}

connections:
- [MyMod_cal_multi_usrp_0, '0', blocks_complex_to_arg_2, '0']
- [MyMod_cal_multi_usrp_0, '0', blocks_complex_to_mag_squared_0, '0']
- [MyMod_cal_multi_usrp_0, '0', blocks_delay_0_0, '0']
- [MyMod_cal_multi_usrp_0, '0', blocks_multiply_xx_0, '1']
- [MyMod_cal_multi_usrp_0, '1', blocks_complex_to_arg_2_0, '0']
- [MyMod_cal_multi_usrp_0, '1', blocks_delay_0_0_0, '0']
- [MyMod_cal_multi_usrp_0, '1', blocks_multiply_xx_0_0, '1']
- [MyMod_cal_multi_usrp_0, '2', blocks_complex_to_arg_2_0_0, '0']
- [MyMod_cal_multi_usrp_0, '2', blocks_delay_0_0_0_0, '0']
- [MyMod_cal_multi_usrp_0, '2', blocks_multiply_xx_0_1, '1']
- [MyMod_cal_multi_usrp_0, '3', blocks_complex_to_arg_2_0_0_0, '0']
- [MyMod_cal_multi_usrp_0, '3', blocks_delay_0_0_0_0_0, '0']
- [MyMod_cal_multi_usrp_0, '3', blocks_multiply_xx_0_1_0, '1']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_arg_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_complex_to_arg_0_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_complex_to_arg_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_arg_1_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_arg_1_0_0, '0', qtgui_time_sink_x_1, '3']
- [blocks_complex_to_arg_1_1, '0', qtgui_time_sink_x_1, '2']
- [blocks_complex_to_arg_2, '0', qtgui_time_sink_x_6, '0']
- [blocks_complex_to_arg_2_0, '0', qtgui_time_sink_x_6, '1']
- [blocks_complex_to_arg_2_0_0, '0', qtgui_time_sink_x_6, '2']
- [blocks_complex_to_arg_2_0_0_0, '0', qtgui_time_sink_x_6, '3']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_7, '0']
- [blocks_complex_to_mag_2, '0', qtgui_time_sink_x_7, '2']
- [blocks_complex_to_mag_3, '0', qtgui_time_sink_x_7, '1']
- [blocks_complex_to_mag_4, '0', qtgui_time_sink_x_7, '3']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_conjugate_cc_0_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_conjugate_cc_0_1_0, '0', blocks_multiply_xx_0_1_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_long_2_0, '5']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_2_0, '4']
- [blocks_delay_0_0_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_delay_0_0_0, '0', ieee802_11_sync_short_0_0, '0']
- [blocks_delay_0_0_0, '0', ieee802_11_sync_short_2_0, '5']
- [blocks_delay_0_0_0_0, '0', blocks_conjugate_cc_0_1, '0']
- [blocks_delay_0_0_0_0, '0', ieee802_11_sync_short_0_1, '0']
- [blocks_delay_0_0_0_0, '0', ieee802_11_sync_short_2_0, '6']
- [blocks_delay_0_0_0_0_0, '0', blocks_conjugate_cc_0_1_0, '0']
- [blocks_delay_0_0_0_0_0, '0', ieee802_11_sync_short_0_1_0, '0']
- [blocks_delay_0_0_0_0_0, '0', ieee802_11_sync_short_2_0, '7']
- [blocks_delay_0_1, '0', ieee802_11_sync_long_0_0, '0']
- [blocks_delay_0_1, '0', ieee802_11_sync_long_2_0, '7']
- [blocks_delay_0_2, '0', ieee802_11_sync_long_0_1, '0']
- [blocks_delay_0_2, '0', ieee802_11_sync_long_2_0, '8']
- [blocks_delay_0_2_1, '0', ieee802_11_sync_long_0_1_0, '0']
- [blocks_delay_0_2_1, '0', ieee802_11_sync_long_2_0, '9']
- [blocks_delay_0_3, '0', ieee802_11_sync_long_2_0, '6']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_1, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0_1_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_2_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_2_0, '1']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_2_0, '2']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_2_0, '3']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_4, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_complex_to_arg_1_1, '0']
- [blocks_divide_xx_1, '0', blocks_complex_to_arg_1_0, '0']
- [blocks_divide_xx_1_0, '0', blocks_complex_to_arg_1_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0_0_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '2']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_2_0, '8']
- [blocks_moving_average_xx_1_0, '0', ieee802_11_sync_short_0_0, '2']
- [blocks_moving_average_xx_1_0, '0', ieee802_11_sync_short_2_0, '9']
- [blocks_moving_average_xx_1_1, '0', ieee802_11_sync_short_0_1, '2']
- [blocks_moving_average_xx_1_1, '0', ieee802_11_sync_short_2_0, '10']
- [blocks_moving_average_xx_1_1_0, '0', ieee802_11_sync_short_0_1_0, '2']
- [blocks_moving_average_xx_1_1_0, '0', ieee802_11_sync_short_2_0, '11']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_multiply_xx_0_1, '0', blocks_moving_average_xx_1_1, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_moving_average_xx_1_1_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_pdu_to_tagged_stream_1_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [blocks_throttle_0, '0', blocks_delay_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0_1_0, '1']
- [blocks_throttle_0_0, '0', blocks_delay_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_throttle_0_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_throttle_0_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0_0_0_0, '0', blocks_delay_0_0, '0']
- [blocks_throttle_0_0_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_null_sink_3, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_vector_to_stream_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', blocks_null_sink_2, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_vector_to_stream_0_0_0_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', blocks_divide_xx_1_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_vector_to_stream_0_0_0_0_0_0, '0', blocks_divide_xx_1, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0_0, '0', blocks_complex_to_arg_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0_0, '0', blocks_divide_xx_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0_0, '0', blocks_divide_xx_1, '1']
- [blocks_vector_to_stream_0_0_0_0_0_0_0, '0', blocks_divide_xx_1_0, '1']
- [blocks_vector_to_stream_0_0_0_0_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0_0_0, '0', blocks_divide_xx_0_0_0, '1']
- [blocks_vector_to_stream_0_0_0_0_1, '0', blocks_null_sink_0_0_0_1, '0']
- [blocks_vector_to_stream_0_0_0_0_2, '0', blocks_file_sink_2_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_2, '0', blocks_null_sink_2, '0']
- [blocks_vector_to_stream_0_0_0_1, '0', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_2, '0', blocks_file_sink_2_0_0, '0']
- [blocks_vector_to_stream_0_0_0_2, '0', blocks_null_sink_1, '0']
- [blocks_vector_to_stream_0_0_1, '0', blocks_null_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_2, '0', blocks_file_sink_2_0, '0']
- [blocks_vector_to_stream_0_0_2, '0', blocks_null_sink_3, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_null_sink_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_null_sink_0_1, '0']
- [blocks_vector_to_stream_0_3, '0', blocks_file_sink_2, '0']
- [blocks_vector_to_stream_0_3, '0', blocks_null_sink_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '1']
- [fft_vxx_0_0, '0', ieee802_11_frame_equalizer_0, '2']
- [fft_vxx_0_1, '0', ieee802_11_frame_equalizer_0, '3']
- [fft_vxx_0_1_0, '0', ieee802_11_frame_equalizer_0, '4']
- [fft_vxx_0_2, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_decode_mac_0_1_0, '0', blocks_pdu_to_tagged_stream_1, pdus]
- [ieee802_11_decode_mac_0_1_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_decode_mac_0_1_0, '0', blocks_vector_to_stream_0_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '0', hsujim_my_csv_0_1_0, '0']
- [ieee802_11_decode_mac_0_1_0, '1', blocks_vector_to_stream_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '1', blocks_vector_to_stream_0_0_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '2', blocks_vector_to_stream_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '2', blocks_vector_to_stream_0_0_0_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '3', blocks_vector_to_stream_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '3', blocks_vector_to_stream_0_0_0_0_0_0_0_0, '0']
- [ieee802_11_decode_mac_0_1_0, '4', blocks_vector_to_stream_0_1, '0']
- [ieee802_11_decode_mac_0_1_0, '5', blocks_vector_to_stream_0_0_0_1, '0']
- [ieee802_11_decode_mac_0_1_0, '6', blocks_vector_to_stream_0_0_0_0_1, '0']
- [ieee802_11_decode_mac_0_1_0, '7', blocks_vector_to_stream_0_0_1, '0']
- [ieee802_11_frame_equalizer_0, '0', blocks_vector_to_stream_0_2, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0_1_0, '0']
- [ieee802_11_frame_equalizer_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [ieee802_11_frame_equalizer_0, '1', blocks_vector_to_stream_0_3, '0']
- [ieee802_11_frame_equalizer_0, '1', ieee802_11_decode_mac_0_1_0, '1']
- [ieee802_11_frame_equalizer_0, '2', blocks_vector_to_stream_0_0_0_0_0_0, '0']
- [ieee802_11_frame_equalizer_0, '2', blocks_vector_to_stream_0_0_0_2, '0']
- [ieee802_11_frame_equalizer_0, '3', blocks_vector_to_stream_0_0_0_0_0_0_0, '0']
- [ieee802_11_frame_equalizer_0, '3', blocks_vector_to_stream_0_0_0_0_2, '0']
- [ieee802_11_frame_equalizer_0, '4', blocks_vector_to_stream_0_0_0_0_0_0_0_0, '0']
- [ieee802_11_frame_equalizer_0, '4', blocks_vector_to_stream_0_0_2, '0']
- [ieee802_11_frame_equalizer_0, symbols, blocks_pdu_to_tagged_stream_1, pdus]
- [ieee802_11_sync_long_2_0, '0', blocks_stream_to_vector_0_2, '0']
- [ieee802_11_sync_long_2_0, '1', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_2_0, '2', blocks_stream_to_vector_0_0, '0']
- [ieee802_11_sync_long_2_0, '3', blocks_stream_to_vector_0_1, '0']
- [ieee802_11_sync_long_2_0, '4', blocks_stream_to_vector_0_1_0, '0']
- [ieee802_11_sync_short_2_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_2_0, '0', ieee802_11_sync_long_2_0, '0']
- [ieee802_11_sync_short_2_0, '1', blocks_delay_0_3, '0']
- [ieee802_11_sync_short_2_0, '1', ieee802_11_sync_long_2_0, '1']
- [ieee802_11_sync_short_2_0, '2', blocks_delay_0_1, '0']
- [ieee802_11_sync_short_2_0, '2', ieee802_11_sync_long_2_0, '2']
- [ieee802_11_sync_short_2_0, '3', blocks_delay_0_2, '0']
- [ieee802_11_sync_short_2_0, '3', ieee802_11_sync_long_2_0, '3']
- [ieee802_11_sync_short_2_0, '4', blocks_delay_0_2_1, '0']
- [ieee802_11_sync_short_2_0, '4', ieee802_11_sync_long_2_0, '4']
- [uhd_usrp_source_0, '0', MyMod_cal_multi_usrp_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_1, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_2_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_5, '0']
- [uhd_usrp_source_0, '1', MyMod_cal_multi_usrp_0, '1']
- [uhd_usrp_source_0, '1', blocks_complex_to_mag_3, '0']
- [uhd_usrp_source_0, '1', blocks_file_sink_2_0_0_1, '0']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_5, '1']
- [uhd_usrp_source_0, '2', MyMod_cal_multi_usrp_0, '2']
- [uhd_usrp_source_0, '2', blocks_complex_to_mag_2, '0']
- [uhd_usrp_source_0, '2', blocks_file_sink_2_0_0_0_0, '0']
- [uhd_usrp_source_0, '2', qtgui_time_sink_x_5, '2']
- [uhd_usrp_source_0, '3', MyMod_cal_multi_usrp_0, '3']
- [uhd_usrp_source_0, '3', blocks_complex_to_mag_4, '0']
- [uhd_usrp_source_0, '3', blocks_file_sink_2_0_1, '0']
- [uhd_usrp_source_0, '3', qtgui_time_sink_x_5, '3']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_xx_0, '1']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_5, '0']
- [uhd_usrp_source_0_0, '1', blocks_delay_0_0_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_multiply_xx_0_0, '1']
- [uhd_usrp_source_0_0, '1', qtgui_time_sink_x_5, '1']
- [uhd_usrp_source_0_0, '2', blocks_delay_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '2', blocks_multiply_xx_0_1, '1']
- [uhd_usrp_source_0_0, '2', qtgui_time_sink_x_5, '2']
- [uhd_usrp_source_0_0, '3', blocks_delay_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '3', blocks_multiply_xx_0_1_0, '1']
- [uhd_usrp_source_0_0, '3', qtgui_time_sink_x_5, '3']

metadata:
  file_format: 1
